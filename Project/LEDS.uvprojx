# Keil uVision project LEDS.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LEDS
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\scr;..\Libraries30\CMSIS\Core\CM3;..\Libraries30\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./scr/: main.c stm32f10x_it.c sysinit.c STM32F1_UART3_Diver.c ds18b20.c STM32_Delay.c STM32F1_ADC1_Diver.c STM32F1_ADC2_Diver.c Stm32F1_Timer2.c Stm32F1_Timer3.c STM32F1_UART1_Diver.c STM32F1_UART2_Diver.c flash_rw.c
  group CMSIS
    ../Libraries30/CMSIS/Core/CM3/: system_stm32f10x.c
    ../Libraries30/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group Stdperiph_lib
    ../Libraries30/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Readme
    ./Readme/: Readme.txt
